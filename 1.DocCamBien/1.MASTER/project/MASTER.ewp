# IAR project MASTER.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library\inc; ..\library\src; ..\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: MASTER.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s103f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: ..\user; ..\library\inc; ..\library\src
  group LIBRARY
    ../library/: STM8CONFIG.h stm8s_conf.h
    ../library/src/: stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group USER
    ../user/: button.c button.h Convert.c Convert.h CreateFrame.c CreateFrame.h Detect.c Detect.h FSM.c FSM.h GetData.c GetData.h gpio.c gpio.h i2c.c i2c.h lcd16x2.c lcd16x2.h main.c MenuLCD.c MenuLCD.h port.c port.h system.c system.h tim.c tim.h uart.c uart.h
