# IAR project uart.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library\inc; ..\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: uart.srec
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group LIBRARY
    ../library/: STM8CONFIG.h stm8s_conf.h
    ../library/src/: stm8s_uart1.c
  group USER
    ../user/: atc.c atc.h atc_user.c atc_user.h main.c uart.c uart.h
