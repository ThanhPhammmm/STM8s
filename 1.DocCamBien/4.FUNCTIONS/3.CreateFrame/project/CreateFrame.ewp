# IAR project CreateFrame.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library\inc; ..\user; ..\..\2.ConvertData\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: CreateFrame.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group LIBRARY
    ../library/: STM8CONFIG.h stm8s_conf.h
  group USER
    ../user/: Convert.c Convert.h CreateFrame.c CreateFrame.h main.c
