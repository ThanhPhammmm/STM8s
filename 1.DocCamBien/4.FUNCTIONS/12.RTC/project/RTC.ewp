# IAR project RTC.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library\inc; ..\library\src; ..\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RTC.srec
  ILINK.IlinkOutputFile: RTC.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group LIBRARY
    ../library/: STM8CONFIG.h stm8s_conf.h
    ../library/src/: stm8s_i2c.c stm8s_uart1.c
  group USER
    ../../../3.PERIPHERAL/3.I2C/user/: i2c.c i2c.h
    ../user/: main.c RTC.c RTC.h tim.c tim.h uart.c uart.h
